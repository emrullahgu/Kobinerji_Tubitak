# Keil uVision project MP2797_Ref_Design_FW_M0.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::..\..\Program Files (x86)\ARM_Compiler_5.06u7)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: OPU_FW_1.4 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F030x8, USE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: Init.c main.c Flash_Config.h Init.h MPF4279x.h MPF4279x_I2C.c BMS_MP279x.h MP279x.h MP279x_I2C.c
software components: CMSIS:CORE 6.1.1, Device:STM32Cube LL:COMMON 1.11.0, Device:STM32Cube LL:I2C 1.11.0, Device:STM32Cube LL:PWR 1.11.0, Device:STM32Cube LL:RCC 1.11.0, Device:STM32Cube LL:UTILS 1.11.0, Device:Startup 1.0.0
